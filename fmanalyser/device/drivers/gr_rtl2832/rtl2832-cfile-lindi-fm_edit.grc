<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['FFT', 'Waterfall', 'Audio']</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Input</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Input</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq_txt</value></param>
<param><key>label</key><value>current</value></param>
<param><key>value</key><value>cur_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>11.0</value></param>
<param><key>num_steps</key><value>110</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim1</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim2</value></param>
<param><key>value</key><value>14</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine</value></param>
<param><key>label</key><value>Tune</value></param>
<param><key>value</key><value>ftune</value></param>
<param><key>min</key><value>-900.0e3</value></param>
<param><key>max</key><value>900.0e03</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>finer</value></param>
<param><key>label</key><value>Fine</value></param>
<param><key>value</key><value>ftune</value></param>
<param><key>min</key><value>-100.0e3</value></param>
<param><key>max</key><value>100.0e03</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sq_thresh</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>value</key><value>mute</value></param>
<param><key>min</key><value>-50.0</value></param>
<param><key>max</key><value>-5.0</value></param>
<param><key>num_steps</key><value>40</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ftune</value></param>
<param><key>label</key><value>Fine Tuning</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>RF Power </value></param>
<param><key>value</key><value>10.0*math.log(rf_pwr_lvl+1.0e-11)/math.log(10)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>lambda x: "%4.1f" % x</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim1</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 115000, 30000)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Frequency Xlating FIR Filter</value></param>
<param><key>samp_rate</key><value>samp_rate/decim1</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Frequency Xlating FIR Filter</value></param>
<param><key>samp_rate</key><value>samp_rate/decim1</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>input_power</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>sq_thresh</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/10)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute</value></param>
<param><key>label</key><value>Mute Level</value></param>
<param><key>value</key><value>-25.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>record</value></param>
<param><key>label</key><value>Record</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>capture_file</value></param>
<param><key>label</key><value>" "</value></param>
<param><key>value</key><value>recfile</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,6,1,6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>35</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>40</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,10,1,1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0 if squelch_probe == 0 else 1.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_pwr_lvl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>input_power</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>squelch_probe</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>input_power</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/tmp/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cur_freq</value></param>
<param><key>value</key><value>frequency+fine+finer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.2e6</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>mute/squelch</value></param>
</block>
<block>
<key>blks2_wfm_rcv</key>
<param><key>id</key><value>blks2_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>samp_rate/decim1</value></param>
<param><key>audio_decimation</key><value>decim2</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0_0</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate/decim1/decim2)</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>WBFM Demodulated</value></param>
<param><key>samp_rate</key><value>int(samp_rate/decim1/decim2)</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>91.6e6</value></param>
<param><key>min</key><value>60e6</value></param>
<param><key>max</key><value>1.8e9</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,8</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>rtl2832_lindi_fm</value></param>
<param><key>title</key><value>lindi fm</value></param>
<param><key>author</key><value>lindi</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>frequency+fine+finer</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blks2_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>input_power</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
