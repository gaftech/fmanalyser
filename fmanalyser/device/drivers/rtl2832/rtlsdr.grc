<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fcd_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 48000, 5000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>nbfm_normal</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>96000</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>gr_simple_squelch_cc</key>
<param><key>id</key><value>gr_simple_squelch_cc_0</value></param>
<param><key>threshold</key><value>-100</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>20000</value></param>
<param><key>width</key><value>1500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_nlog10_ff</key>
<param><key>id</key><value>gr_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_probe_signal_f</key>
<param><key>id</key><value>power_probe</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>value</key><value>91600000</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>tuner_name</key><value></value></param>
<param><key>read_length</key><value>0</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>xtal_freq</key><value>0</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_normal</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>gr_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_simple_squelch_cc_0</source_block_id><sink_block_id>nbfm_normal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nlog10_ff_0</source_block_id><sink_block_id>power_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
